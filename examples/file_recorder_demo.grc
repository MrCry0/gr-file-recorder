options:
  parameters:
    author: Oleksandr Suvorov
    description: 'Demo flowgraph: cosine source through a throttle into the File Recorder Sink. Click the toolbar button to start/stop recording.'
    generate_options: qt_gui
    id: file_recorder_demo
    output_language: python
    placement: '[0, 0]'
    title: gr-file-recorder demo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: file_recorder_sink_0
  id: file_recorder_sink
  parameters:
    button_style: top
    button_type: toggle
    show_template: 'True'
    counter_start: '1'
    counter_step: '1'
    counter_style: 0-padded
    date_format: '%Y%m%d-%H%M%S'
    file_template: capture_{{samp_rate}}_{date}_{counter}
    input_type: complex
    max_file_size: '0'
    record_duration: '0'
    vlen: '1'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', file_recorder_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
